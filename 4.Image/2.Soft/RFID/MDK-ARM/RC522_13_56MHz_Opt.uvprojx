# Keil uVision project RC522_13_56MHz_Opt.uvprojx, settings and files
target RC522_13_56MHz_Opt Configuration (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: RC522_13_56MHz_Opt Configuration +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ../Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc;          ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Include;          ../Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051x8.s
  group Application/User
    ../Src/: stm32f0xx_it.c main.c stm32f0xx_hal_msp.c i2c.c gpio.c usart.c beep_opt.c lcd.c RC522_Opt.c tim.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
software components: CMSIS:CORE 4.1.0
